options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: lora_receive_realtime
    output_language: python
  states: {}

blocks:
- name: bitrate
  id: variable
  parameters:
    value: sf * (1 / (2**sf / float(bw)))
  states: {}
- name: bw
  id: variable
  parameters:
    value: '125000'
  states: {}
- name: capture_freq
  id: variable
  parameters:
    value: 915.0e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: sf
  id: variable
  parameters:
    value: '7'
  states: {}
- name: symbols_per_sec
  id: variable
  parameters:
    value: float(bw) / (2**sf)
  states: {}
- name: target_freq
  id: variable
  parameters:
    value: 915.0e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: lora_lora_receiver_0
  id: lora_lora_receiver
  parameters:
    bandwidth: bw
    center_freq: capture_freq
    channel_list: '[target_freq]'
    conj: 'False'
    cr: '4'
    crc: 'True'
    decimation: '10'
    disable_channelization: 'False'
    disable_drift_correction: 'False'
    implicit: 'False'
    reduced_rate: 'False'
    samp_rate: samp_rate
    sf: sf
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: capture_freq
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_throttle_0, '0', lora_lora_receiver_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
